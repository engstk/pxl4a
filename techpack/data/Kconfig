## techpack/data/Kconfig
```kconfig
source "techpack/data/drivers/rmnet/perf/Kconfig"
source "techpack/data/drivers/rmnet/shs/Kconfig"
#source "techpack/data/drivers/emac-dwc-eqos/Kconfig"
```
